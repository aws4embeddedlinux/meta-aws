FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-Disable-runtime_lib_dirs-for-cross-compile.patch"