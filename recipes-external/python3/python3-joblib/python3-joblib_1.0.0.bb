SUMMARY = "Lightweight pipelining: using Python functions as pipeline jobs"
HOMEPAGE = "https://github.com/joblib/joblib"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=32b289008fb813a27c9025f02b59d03d"

PYPI_PACKAGE = "joblib"

SRC_URI[md5sum] = "ce894d0d3fdb83b9ad545318af0cba3d"
SRC_URI[sha256sum] = "7ad866067ac1fdec27d51c8678ea760601b70e32ff1881d4dc8e1171f2b64b24"

inherit pypi
inherit setuptools3