inherit setuptools3
require aws-greengrass-core-sdk-python.inc

SRCREV = "c58db71144ec05ca3db2f920c0a0d4c04eef3d18"
