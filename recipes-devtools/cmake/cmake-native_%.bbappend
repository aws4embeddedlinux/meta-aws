FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-FortranCInterface-Fix-broken-search-for-test-exe-whe.patch"