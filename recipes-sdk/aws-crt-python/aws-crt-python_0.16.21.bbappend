FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-aws-crt-python-remove-static-library-search-from-set.patch"

