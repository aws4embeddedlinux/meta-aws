inherit setuptools3
require aws-iot-device-sdk-python-v2.inc